Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-08-23T14:56:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 2015.0.2014.0223 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 23 14:56:59 2017 * Host: RemoteThinktank * Database: C:\Users\User-PC\AppData\Local\Temp\{AF8B4A82-4293-4F7F-A255-217BA2193701}\ifc * Database version: 5507 * Database creation date: Wed Aug 23 14:56:58 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 23 14:56:59 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 23 14:56:59 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -33, -52, -1, -696472; RefLongitude: 151, 12, 25, 587158; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, 1 Ground Floor - Fine
LongName: 1 Ground Floor - Fine; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 1 Ground Floor - Fine; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: Level Head - Triangle (AUS): Type 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: XS4 One Escutcheon Brass Polished Finish, Lock-Door-Salto_Systems-XS4_One_Escutcheons:XS4 One Escutcheon Brass Polished Finish:1049965
In: 1 Ground Floor - Fine
Material: Brass - Salto Systems - Polished, Plastic - Salto Systems - Black
Pset_BuildingElementProxyCommon - Reference: XS4 One Escutcheon Brass Polished Finish
Pset_ManufacturerTypeInformation - Manufacturer: Salto Systems
Constraints - Offset: -5996.12 mm; Work Plane: <not associated>
Construction - Panel Thickness: 25 mm; Mounting Height: 1000 mm
Dimensions - Area: 0.0542917 m2; Depth: 218 mm; Height: 285 mm; Volume: 0.000701569 m3; Width: 42 mm
Identity Data - Mark: 238; Part Description: XS4 One Escutcheon; Part Number: Ex750; Copyright: Copyright © Salto Systems; Date Created: March 2, 2017; Date Modified: March 2, 2017; Description: XS4 One Escutcheon; Equipment Abbreviation: DH; Family Version: 1.0; Manufacturer: Salto Systems; Model: Ex750; Model Disclaimer: Contact Salto Systems for more information; OmniClass Number: 23.17.19.11; Product Page URL: http://www.saltosystems.com/en-us/product-range/product/73/xs4-escutcheons/; Type Name: XS4 One Escutcheon Brass Polished Finish; URL: http://www.saltosystems.com/
Other - Category: Security Devices; Family: Lock-Door-Salto_Systems-XS4_One_Escutcheons: XS4 One Escutcheon Brass Polished Finish; Family and Type: Lock-Door-Salto_Systems-XS4_One_Escutcheons: XS4 One Escutcheon Brass Polished Finish; Type: Lock-Door-Salto_Systems-XS4_One_Escutcheons: XS4 One Escutcheon Brass Polished Finish; Type Id: Lock-Door-Salto_Systems-XS4_One_Escutcheons: XS4 One Escutcheon Brass Polished Finish; Family Name: Lock-Door-Salto_Systems-XS4_One_Escutcheons
Phasing - Phase Created: New Construction
Materials and Finishes - Product Material: Brass - Salto Systems - Polished
